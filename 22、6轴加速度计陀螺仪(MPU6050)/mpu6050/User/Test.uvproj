# Keil uVision project Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: Test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src;..\User
  group Source Group 1
    ./: main.c
    ../src/: dig_c.c hc165.c member.c mySPI.c uart.c Myiic.c MPU6050.c oled.c
