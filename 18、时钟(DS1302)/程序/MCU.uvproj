# Keil uVision project MCU.uvproj, settings and files
target My Designer (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: MCU +hex
  c flags: Optimize=8 SizeSpeed=1
  group 时钟
    ./: MCU.c DS1302.c LCD1602.c
