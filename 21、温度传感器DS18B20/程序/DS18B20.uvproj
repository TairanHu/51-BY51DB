# Keil uVision project DS18B20.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DS18B20 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 1602.c DS18B20.c main.c
