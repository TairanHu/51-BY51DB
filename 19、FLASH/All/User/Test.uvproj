# Keil uVision project Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src;..\User
  group Source Group 1
    ./: main.c
    ../src/: member.c oled.c flash.c mySPI.c led_Array.c timer.c
